# Keil uVision project USBCDC_Serial_Skelton.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: USBCDC_Serial +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base;.\code\source;.\code\include;.\code\source\FIFO_RW\Keil_FIFO_RW source
  asm include: as above
  group ASM
    ./code/A51/: STARTUP.A51
  group Main
    ./code/source/: USB_CDC_UART.c USB_Class_Requests.c USB_Descriptor.c USB_ISR.c USB_Main.c USB_Standard_Requests.c
  group FIFO_RW
    ./code/source/FIFO_RW/Keil_FIFO_RW source/: FIFO_RD_XD.a51 FIFO_WT_CD.a51 FIFO_WT_XD.a51
